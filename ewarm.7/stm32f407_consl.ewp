# IAR project stm32f407_consl.ewp, settings and files
configuration stm32f407_consl (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; HSE_VALUE=8000000; STM32F40_41xxx; ARM_MATH_CM4; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..; ..\comport; ..\log; ..\sys; ..\math; ..\menu; ..\periph; ..\sensors; ..\eeprom; ..\proto; ..\usb; ..\utils; ..\Library\CMSIS\Include; ..\Library\CMSIS\Device\ST\STM32F4xx\Include; ..\Library\STM32F407-Discovery; ..\Library\STM32F4xx_StdPeriph_Driver\inc; ..\Library\STM32_USB_Device_Library\Class\cdc\inc; ..\Library\STM32_USB_Device_Library\Class\msc\inc; ..\Library\STM32_USB_Device_Library\Class\msc_cdc_wrapper\inc; ..\Library\STM32_USB_Device_Library\Core\inc; ..\Library\STM32_USB_OTG_Driver\inc; ..\Library\FreeRTOS\Source\include; ..\Library\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\Library\display; ..\Library\keyboard
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: loader.bin
  ILINK.IlinkOutputFile: stm32f407_consl.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group comport
    ../comport/: vcp.c
  group eeprom
    ../eeprom/: eeprom.c eeprom_emul.c
  group Library/CMSIS
    ../library/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group Library/display
    ../library/display/: dogm128.c dogmcb.c dogmch.c dogmcmp.c dogmcp.c dogmcv.c dogmda.c dogmdl.c dogmdp.c dogmds.c dogmdsp.c dogmfont.c dogmitoa.c dogmma.c dogmoi.c dogmop.c dogmov.c dogmsb.c dogmsd.c dogmsh.c dogmsm.c dogmsmp.c dogmsp.c dogmspi.c dogmsv.c dogmsysc.c dogmsysgr.c dogmsysi.c dogmxb.c dogmxh.c dogmxp.c dogmxv.c font_4x6.c font_5x7.c font_5x8.c font_6x10.c font_6x12.c font_6x13.c font_6x13b.c font_6x9.c font_7x13.c font_7x14.c font_7x14b.c font_8x13.c font_9x15.c font_9x15b.c font_9x18.c font_9x18b.c libinfo.c
  group Library/FreeRTOS
    ../library/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../library/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../library/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library/keyboard
    ../library/keyboard/: keyb.c
  group Library/STM32_USB_Device_Library/Class/CDC
    ../library/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group Library/STM32_USB_Device_Library/Class/MSC
    ../library/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group Library/STM32_USB_Device_Library/Core
    ../library/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group Library/STM32_USB_OTG_Driver
    ../library/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group Library/stm32f4_discovery
    ../library/STM32F407-Discovery/: stm32f4_discovery.c
  group Library/STM32F4xx_StdPeriph_Driver
    ../library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group math
    ../math/: convert.c
  group menu
    ../menu/: indic.c menu.c
  group periph
    ../periph/: i2c1.c led.c rtc.c spi.c timer.c
  group proto
    ../proto/: status.c
  group sensors
    ../sensors/: adc.c dynament.c lmp91k.c sensor.c
  group sys
    ../sys/: stm32f4xx_it.c system_stm32f4xx.c
  group usb
    ../usb/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group utils
    ../utils/: circbuf.c crc16.c userfunc.c
