<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stm32f407_consl.ewp</path>
  </project>
  <batchBuild/>
</workspace>


